# Keil uVision project STM32F411.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\interface;..\HARDWARE\interface;..\FWLIB\inc;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group SYSTEM
    ../SYSTEM/src/: delay.c sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group HARDWARE
    ../HARDWARE/src/: led.c myiic.c mpu9250.c
